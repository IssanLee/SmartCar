# IAR project SmartCar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEFAULT_K60; USE_K60DZ10
  ICCARM.CCIncludePath2: ..\App; ..\App\Config; ..\Board\LCD; ..\Board\KEY; ..\Lib\Chip; ..\Lib\Chip\Cpu; ..\Lib\Chip\Driver; ..\Lib\Common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SmartCar.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\Lib\Config\LPLD_K60DN512_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../App/: app.c
  group App/Config
    ../App/Config/: CustomKeyword.txt k60_Config.h
  group App/Menu
    ../App/Menu/: menu.c menu.h
  group Board/GYRO
    ../Board/GYRO/: L3G4.c L3G4.h
  group Board/KEY
    ../Board/KEY/: KEY.c KEY.h
  group Board/LCD
    ../Board/LCD/: ASCII.c ASCII.h LCD.c LCD.h ST7735R.c ST7735R.h
  group Board/LED
    ../Board/LED/: LED.c LED.h
  group Board/NRF
    ../Board/NRF/: NRF24L01.c NRF24L01.h
  group Board/PC
    ../Board/PC/: Computer.c Computer.h
  group Lib/Chip
    ../Lib/Chip/: Drivers.h
  group Lib/Chip/Cpu
    ../Lib/Chip/Cpu/: MK60DZ10.h startup_K60DZ10.s system_MK60.c system_MK60DZ10.h
  group Lib/Chip/Driver
    ../Lib/Chip/Driver/: ADC.c ADC.h DAC.c DAC.h DMA.c DMA.h FTM.c FTM.h GPIO.c GPIO.h I2C.c I2C.h LPTMR.c LPTMR.h MCG.c MCG.h NVIC.c NVIC.h PIT.c PIT.h SPI.c SPI.h SYSTICK.c SYSTICK.h UART.c UART.h WDOG.c WDOG.h
  group Lib/Common
    ../Lib/Common/: alloc.c assert.c assert.h common.h io.c io.h lib_def.h printf.c queue.c queue.h relocate.c relocate.h stdlib.c stdlib.h uif.c uif.h
