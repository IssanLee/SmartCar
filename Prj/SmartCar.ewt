<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App</name>
    <group>
      <name>Common</name>
    </group>
    <group>
      <name>Config</name>
      <file>
        <name>$PROJ_DIR$\..\App\Config\CustomKeyword.txt</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\App\Config\k60_Config.h</name>
      </file>
    </group>
    <group>
      <name>Menu</name>
      <file>
        <name>$PROJ_DIR$\..\App\Menu\menu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\App\Menu\menu.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\App\app.c</name>
    </file>
  </group>
  <group>
    <name>Board</name>
    <group>
      <name>GYRO</name>
      <file>
        <name>$PROJ_DIR$\..\Board\GYRO\L3G4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\GYRO\L3G4.h</name>
      </file>
    </group>
    <group>
      <name>KEY</name>
      <file>
        <name>$PROJ_DIR$\..\Board\KEY\KEY.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\KEY\KEY.h</name>
      </file>
    </group>
    <group>
      <name>LCD</name>
      <file>
        <name>$PROJ_DIR$\..\Board\LCD\ASCII.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\LCD\ASCII.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\LCD\LCD.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\LCD\LCD.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\LCD\ST7735R.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\LCD\ST7735R.h</name>
      </file>
    </group>
    <group>
      <name>LED</name>
      <file>
        <name>$PROJ_DIR$\..\Board\LED\LED.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\LED\LED.h</name>
      </file>
    </group>
    <group>
      <name>NRF</name>
      <file>
        <name>$PROJ_DIR$\..\Board\NRF\NRF24L01.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\NRF\NRF24L01.h</name>
      </file>
    </group>
    <group>
      <name>PC</name>
      <file>
        <name>$PROJ_DIR$\..\Board\PC\Computer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\PC\Computer.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>Lib</name>
    <group>
      <name>Chip</name>
      <group>
        <name>Cpu</name>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Cpu\MK60DZ10.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Cpu\startup_K60DZ10.s</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Cpu\system_MK60.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Cpu\system_MK60DZ10.h</name>
        </file>
      </group>
      <group>
        <name>Driver</name>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\ADC.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\ADC.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\DAC.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\DAC.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\DMA.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\DMA.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\FTM.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\FTM.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\GPIO.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\GPIO.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\I2C.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\I2C.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\LPTMR.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\LPTMR.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\MCG.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\MCG.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\NVIC.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\NVIC.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\PIT.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\PIT.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\SPI.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\SPI.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\SYSTICK.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\SYSTICK.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\UART.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\UART.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\WDOG.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\Chip\Driver\WDOG.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\Lib\Chip\Drivers.h</name>
      </file>
    </group>
    <group>
      <name>Common</name>
      <file>
        <name>$PROJ_DIR$\..\Lib\Common\alloc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\Common\assert.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\Common\assert.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\Common\common.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\Common\io.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\Common\io.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\Common\lib_def.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\Common\printf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\Common\queue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\Common\queue.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\Common\relocate.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\Common\relocate.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\Common\stdlib.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\Common\stdlib.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\Common\uif.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\Common\uif.h</name>
      </file>
    </group>
  </group>
</project>


